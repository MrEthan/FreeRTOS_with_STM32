# Keil uVision project FreeRTOS_V10.0.1_STM32.uvprojx, settings and files
target STM32F103ZE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS_V10.0.1_STM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Source\Drivers\LED;..\Source\Drivers\USART;..\Source\FreeRTOS;..\Source\FreeRTOS\include;..\Source\FreeRTOS\portable\RVDS\ARM_CM3;..\Source\Public;..\Source\User\inc;..\Source\User\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Drivers
    ../Source/Drivers/LED/: LED.c
    ../Source/Drivers/USART/: usart.c
  group FreeRTOS
    ../Source/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../Source/FreeRTOS/portable/MemMang/: heap_2.c
    ../Source/FreeRTOS/: queue.c list.c tasks.c
  group Public
    ../Source/Public/: system.c
  group Users
    ../Source/User/src/: main.c
    ../Source/User/: readme.txt
software components: CMSIS:CORE 5.0.1, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
